# Keil uVision project BallPlate_Beta.uvprojx, settings and files
target BallPlate_KF (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BallPlate_Beta
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_MCBSTM32, __CC, _ARM
  c include: .\Application;.\Hardware;.\CMSIS;.\Driver;.\Service
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s
  group Application
    ./Application/: main.c Abstract.txt Controller.c Estimation.c UserDef.h
  group Service
    ./Service/: service_com.c service_led.c KalmanLib2.c usart_retarget.c KalmanLib3.c
  group Driver
    ./Driver/: stm32_gpio.c stm32_pwm.c stm32_usart.c
  group CMSIS
    ./CMSIS/: core_cm3.c STM32_Init.c system_stm32f10x.c
  group Hardware
    ./Hardware/: platform_cfg.h stm32f10x.h BallPlate_Plant.h
software components: CMSIS:CORE 5.0.1
